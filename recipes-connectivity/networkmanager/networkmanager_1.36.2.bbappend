
RREPLACES_${PN} = "connman"
