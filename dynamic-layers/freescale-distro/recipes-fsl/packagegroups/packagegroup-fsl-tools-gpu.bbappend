SOC_TOOLS_GPU:append_imxgpu = " \
	imx-gpu-sdk \
	imx-gpu-viv-tools \
"

