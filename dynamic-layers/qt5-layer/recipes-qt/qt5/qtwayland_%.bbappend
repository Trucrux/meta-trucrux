PACKAGECONFIG:remove_mx6 = "xcomposite-egl xcomposite-glx"
PACKAGECONFIG:remove_mx7 = "xcomposite-egl xcomposite-glx"
