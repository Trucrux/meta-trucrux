# add more runtime dependencies
RDEPENDS_${PN}:append = " \
	qtmultimedia-plugins \
	qtmultimedia-qmlplugins \
	qtsvg-plugins \
	qtxmlpatterns-qmlplugins \
"
