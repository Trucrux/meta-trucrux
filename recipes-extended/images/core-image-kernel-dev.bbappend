KERNEL_DEV_UTILS = "dropbear ${NETWORK_MANAGER}"
